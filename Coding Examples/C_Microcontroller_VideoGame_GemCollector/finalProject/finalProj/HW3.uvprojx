# Keil uVision project HW3.uvprojx, settings and files
target HW3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.h main.c tic_tac_toe.c tic_tac_toe.h tic_tac_toe_images.c tic_tac_toe_images.h hw3_lib.h
    ../ICE-20-SPI-Nordic/: interrupts.c interrupts.h
  group drivers
    ../drivers/c/: adc.c gpio_port.c timers.c i2c.c pc_buffer.c spi.c uart.c
    ../drivers/include/: adc.h driver_defines.h gpio_port.h i2c.h interrupts.h pc_buffer.h spi.h timers.h uart.h
    ./: changecodefile.c
  group peripherals
    ../peripherals/c/: launchpad_io.c lcd.c ps2.c ece353_images.c eeprom.c ft6x06.c lcd_images.c serial_debug.c spi_select.c wireless.c ws2812b.s
    ../peripherals/include/: ece353_images.h eeprom.h ft6x06.h io_expander.h launchpad_io.h lcd.h lcd_images.h ps2.h serial_debug.h spi_select.h validate.h wireless.h ws2812b.h ws2812b_effects.h
    ./: io_expander.c
  group lib
    ./lib/: ece353_hw3_validate.lib ece353_hw3.lib
    ../lib/: ECE353-Validate.lib
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
